Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-07-13T11:21:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 13 11:21:31 2017 * Host: Calatrava * Database: D:\AppData\Local\Temp\{537F56E7-10F8-4452-B6D8-6F7ECAC4599D}\ifc * Database version: 5507 * Database creation date: Thu Jul 13 11:21:28 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 13 11:21:28 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 13 11:21:28 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 cm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 cm
Other - Category: Levels; Family Name: Level; Family: Level: 1/4" Head; Family and Type: Level: 1/4" Head; Type: Level: 1/4" Head; Type Id: Level: 1/4" Head
Identity Data - Type Name: 1/4" Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 cm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 cm
Graphics - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: KDW030073 Ellipso Duo Oval 1900x1000x465, KDW030073 Ellipso Duo Oval 1900x1000x465:KDW030073 Ellipso Duo Oval 1900x1000x465:314192
In: Level 1
Material: Kaldewei
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI
Pset_DistributionFlowElementCommon - Reference: KDW030073 Ellipso Duo Oval 1900x1000x465
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 cm
Dimensions - Area: 30.4745 ft2; Volume: 0.315757 ft3
Identity Data - Mark: 1; Description: KALDEWEI international Worldwide partner for iconic bathroom solutions made of KALDEWEI steel enamel KALDEWEI steel enamel delivers unique advantages that inspire excellence in bathroom design. Projects across the world, from upmarket hotels to private homes, capture the sophisticated aesthetic that recommends KALDEWEI as the partner of choice. As a leading international manufacturer of high-quality shower surfaces, bathtubs and washbasins made of superior steel enamel, KALDEWEI today is present in more than 80 countries.; Manufacturer: KALDEWEI; Model: Ellipso Duo Oval 1900x1000x465; Type Comments: Model No. 232: The soft, elliptical inner contour of ELLIPSO DUO OVAL promises a new sense of security and comfort. The rounded shoulder section and carefully calibrated side walls create a generous space in which to lean back and relax, either alone or with a partner.; Type Name: KDW030073 Ellipso Duo Oval 1900x1000x465; URL: https://www.kaldewei.com; Version: 1
Other - Category: Plumbing Fixtures; Family: KDW030073 Ellipso Duo Oval 1900x1000x465: KDW030073 Ellipso Duo Oval 1900x1000x465; Family and Type: KDW030073 Ellipso Duo Oval 1900x1000x465: KDW030073 Ellipso Duo Oval 1900x1000x465; Type: KDW030073 Ellipso Duo Oval 1900x1000x465: KDW030073 Ellipso Duo Oval 1900x1000x465; Type Id: KDW030073 Ellipso Duo Oval 1900x1000x465: KDW030073 Ellipso Duo Oval 1900x1000x465; Family Name: KDW030073 Ellipso Duo Oval 1900x1000x465; Features: https://www.kaldewei.co.uk/products/baths/detail/product/ellipso-duo-oval/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=232&cHash=6eb054f4bda3afba7937520e36b87930#tabConfiguration; ManufacturerEmail: info@kaldewei.de; Polantis code: KDW030073; SerialNumber: 232; Shape: Oval baths; Sustainability: https://kaldewei-fa.secure.footprint.net/data/sprachen/englisch/prospekte/rest/Steel_Enamel_Baths_and_Shower_Trays.pdf; WarrantyDurationUnit: Year
Phasing - Phase Created: New Construction
Data - ColourOptions: https://www.kaldewei.co.uk/inspiration/material/colours/; Durability: https://EN 14516; IntegralAccessories: https://www.kaldewei.co.uk/products/baths/detail/product/ellipso-duo-oval/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=232&cHash=6eb054f4bda3afba7937520e36b87930#tabConfiguration; Name: Ellipso Duo Oval 1900x1000x465; Size: 1900x1000x465; SupportFrame: https://www.kaldewei.co.uk/products/baths/detail/product/ellipso-duo-oval/?tx_wkkaldeweiproducts_product%5Bmodellnr%5D=232&cHash=6eb054f4bda3afba7937520e36b87930#tabConfiguration; VolumeToOverflowMaximum: 214; WarrantyDurationParts: 30; WaterSupplyOverflowAndWasteHolesOverflow: 52 mm; WaterSupplyOverflowAndWasteHolesWaste: 52 mm; WaterSupplyOverflowAndWasteHolesWaterSupply: n/a; Weight: 55
General - Author: Polantis; ManufacturerCountry: GERMANY; ManufacturerName: KALDEWEI; Material: steel enamel; ObjectName: ELLIPSO DUO OVAL 1900x1000x465; ObjectNorm: EN 14516 EU DECLARATION OF PERFORMANCE (https://www.kaldewei.de/fileadmin/data/sprachen/alle/pdfs/leistungserkla__rungBW-DW-WT-0216Web.pdf); ProductInformation: Model No. 232: The soft, elliptical inner contour of ELLIPSO DUO OVAL promises a new sense of security and comfort. The rounded shoulder section and carefully calibrated side walls create a generous space in which to lean back and relax, either alone or with a partner.; TechnicalDataURL: https://kaldewei.typo-live.web-factory.de/fileadmin/data/sprachen/englisch/techdata/KADBE_CLASSICDUOOVAL______1113_.pdf; Uniclass 2015: Pr_40_20_06_08; UNSPSCCode: 30181500; UNSPSCNames: Sanitary ware; WarrantyStartDate: https://www.kaldewei.co.uk/fileadmin/data/sprachen/englisch/prospekte/rest/GB_GUARANTEE__CARE_AND_INSTALLATION_INSTRUCTIONS.pdf
Materials and Finishes - Color: https://www.kaldewei.co.uk/inspiration/material/colours/; Finish: https://www.kaldewei.co.uk/products/baths/extras-installation/surfaces/; Finition: Kaldewei; PanelMaterial: n/a
Structural - Sound Insulation: DIN 4109:2016; VDI4100:2012
